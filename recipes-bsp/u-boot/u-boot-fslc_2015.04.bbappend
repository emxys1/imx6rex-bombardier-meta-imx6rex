FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
 
SRC_URI += "file://0001-First-changeset.patch"
SRC_URI += "file://0001-U-Boot-display-on-UART2.patch"
